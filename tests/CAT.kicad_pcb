# Repository devbisme/HierPlace

File README.md:

# XESS Hierarchical Placement Plugin

This PCBNEW plugin arranges the parts into groups that reflect
the hierarchy in the design.

* Free software: MIT license

## Features

* Creates an arrangement of the parts that reflects their level in the design hierarchy.
* Will arrange only the parts that have been selected or, if no parts are selected, the entire design.
* Will not move locked parts.

## Installation

On linux, just copy `HierPlace.py` to your local `~/.kicad_plugins` directory.

## Usage

There are two ways to use this plugin:

1. Press the `Tools => External Plugins... => HierPlace` button and all the unlocked
   parts will be arranged.

2. Select a subset of the parts and press the `HierPlace` button and only the unlocked
   parts in the selection will be arranged.

### Example

Here is an example of an initial arrangement of parts in PCBNEW.
The SDRAM BGA and its seven decoupling capacitors are highlighted to show
how widely separated they are. Other sections of the circuitry are similarly scattered.

The arrangement after running `HierPlace` is shown below.
Now the SDRAM and its decoupling capacitors are closely grouped, as are the
other sections of the circuitry.

## Credits

### Development Lead

* XESS Corp. <info@xess.com>

### Contributors

None yet. Why not be the first?

## KiCad design tests/CAT.kicad_pcb

Board: 4 copper layers, 65.0 x 56.0 mm, 111 parts (57 on the bottom side), 168 nets.

Parts:
C1: 100uF; c_elec_6.3x5.3
C2, C3, C4, C6, C32, C33: 10uF; C_0805
C5, C8, C10, C12, C14, C16, C17, C18, C19, C24, C25, C26, C27, C34, C35, C40, C41, C42, C44, C45, C47, C48: 0.1uF; C_0603
C9, C11, C13, C20, C21, C22, C23, C28, C29, C30, C31, C38, C39: 1.0uF; C_0603
C43, C46: 0.01uF; C_0603
CON1: BARREL_JACK
D1: D; SOD-323
GPIO1: RPi_GPIO; Pin_Header_Straight_2x20
GR1, GR2, GR3, GR4, GR5: Grove; GROVE_MALE
HDR1: CONN_02X10; Pin_Header_Straight_2x10
JP1, JP5: JUMPER; S_JUMPER_2
JP2, JP3, JP4, JP6: JUMPER3; HDR_1x3
LED1, LED2, LED3, LED4: LED; LED-0603
PM2, PM3: PMOD_SCKT-12
Q1: Q_PMOS_GSD; SOT-23
R1, R6, R7: 100; R_0603
R2, R3, R4, R5: 127; R_0402
R8: 1260; R_0805_HandSoldering
R9: 768; R_0603
RESET1: SW_PUSH; RS-282G05A3-SM_RT
RN1, RN3, RN4, RN9, RN10, RN11: 4.7K; CTS_742C043
RN2: 100; CTS_742C043
RN5, RN6, RN12: 100; CTS_742C083
RN7, RN8: 200; CTS_742C083
SATA1, SATA2: SATA_CONN; SATA-MOLEX-67491
SH1, SH2, SH3, SH4, SH5, SH6: JSHORTNORMAL; xess-JSHORT
SW1, SW2: SW_PUSH; RS-282G05A3-SM_RT
SW3: DIPSW4; xess-DS-04
TP-1.2V1, TP-3.3V1, TP-5V1: TPTP-COMPACT; Measurement_Point_Round-TH_Small
TP-GND1: TPTP-COMPACT; Measurement_Point_Round-TH_Small
U1: AZ1117EH-3.3; SOT-223
U2: I2C Flash; SOIC-8-N
U3: AZ1117EH-1.2; SOT-223
U4: iCE40-HX8K-CT256; Lattice_caBGA_256
U5: 16Mx16 SDRAM; TSOPII-54
U6: SPI Flash; SOIC-8-N
U7: 100 MHz Osc; 2.5x3.2
U8: AZ1117EH-ADJ; SOT-223

Connections:
+1.2V: C4.1, C38.1, C40.1, C42.1, C44.1, C45.1, C46.1, R1.2, R6.2, TP-1.2V1.1, U3.2, U3.4, U4.A14, U4.F6, U4.F10, U4.K6, U4.K10, U4.L2
+3.3V: C3.1, C5.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C16.1, C17.1, C18.1, C20.1, C21.1, C22.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C39.1, C41.1, C43.1, C47.1, C48.1, D1.2, GR1.3, GR2.3, GR3.3, JP2.3, JP3.3, RN1.1, RN1.2, RN3.3, RN3.4, RN4.3, RN4.4, RN9.1, RN9.2, RN10.1, RN10.2, RN11.1, RN11.2, SH3.2, SH4.2, TP-3.3V1.1, U1.2, U1.4, U2.7, U2.8, U3.3, U4.A3, U4.A8, U4.A13, U4.C15, U4.F8, U4.H10, U4.H15, U4.K8, U4.N13, U4.N15, U4.P3, U4.R8, U4.R13, U5.1, U5.3, U5.9, U5.14, U5.27, U5.43, U5.49, U6.3, U6.7, U6.8, U7.1, U7.4
+5V: C1.1, C2.1, JP2.1, JP3.1, Q1.2, TP-5V1.1, U1.3, U8.3
+5V-RPi: GPIO1.2, GPIO1.4, JP4.3, SH1.2
/SATA1_A_N: R2.1, RN7.2, SATA1.3
/SATA1_A_P: R2.2, RN7.1, SATA1.2
/SATA1_B_N: R3.2, RN7.3, SATA1.5
/SATA1_B_P: R3.1, RN7.4, SATA1.6
/SATA2_A_N: R4.1, RN8.2, SATA2.3
/SATA2_A_P: R4.2, RN8.1, SATA2.2
/SATA2_B_N: R5.2, RN8.3, SATA2.5
/SATA2_B_P: R5.1, RN8.4, SATA2.6
BCM0_ID_SD: GPIO1.27, RN1.4, U2.5
BCM1_ID_SC: GPIO1.28, RN1.3, U2.6
BCM2_SDA: GPIO1.3, U4.R16
BCM3_SCL: GPIO1.5, U4.T16
BCM4_GPCLK0: GPIO1.7, U4.R9
BCM5: GPIO1.29, U4.T6
BCM6: GPIO1.31, U4.T5
BCM7_CE1: GPIO1.26, U4.T7
BCM8_CE0: GPIO1.24, U4.T8
BCM9_MISO: GPIO1.21, RN12.2
BCM10_MOSI: GPIO1.19, RN12.1
BCM11_SCLK: GPIO1.23, RN12.4
BCM12: GPIO1.32, U4.R6
BCM13: GPIO1.33, U4.R5
BCM14_TXD: GPIO1.8, U4.T15
BCM15_RXD: GPIO1.10, U4.T14
BCM16: GPIO1.36, U4.R4
BCM17: GPIO1.11, JP1.1, SH5.2, U4.T13
BCM18_PCM_C: GPIO1.12, U4.T11
BCM19_MISO: GPIO1.35, U4.T3
BCM20_MOSI: GPIO1.38, U4.R3
BCM21_SCLK: GPIO1.40, U4.T1
BCM22: GPIO1.15, JP5.1, SH6.2, U4.T10
BCM23: GPIO1.16, U4.P9
BCM24: GPIO1.18, U4.T9
BCM25: GPIO1.22, RN12.3
BCM26: GPIO1.37, U4.T2
BCM27_PCM_0: GPIO1.13, U4.R10
DIPSW1: SW3.8, U4.C6
DIPSW2: SW3.7, U4.C5
DIPSW3: SW3.6, U4.C4
DIPSW4: SW3.5, U4.C3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, CON1.2, GPIO1.6, GPIO1.9, GPIO1.14, GPIO1.20, GPIO1.25, GPIO1.30, GPIO1.34, GPIO1.39, GR1.4, GR2.4, GR3.4, GR4.4, GR5.4, HDR1.15, JP6.3, PM2.5, PM2.11, PM3.5, PM3.11, Q1.1, R7.1, R8.2, RN2.1, RN2.2, RN5.5, RN5.6, RN5.7, RN5.8, RN6.5, RN6.6, RN6.7, RN6.8, SATA1.1, SATA1.4, SATA2.1, SATA2.4, SH2.1, TP-GND1.1, U1.1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
GR1-IO1: GR1.1, RN9.4, U4.C10
GR1-IO2: GR1.2, RN9.3, U4.C9
GR2-IO1: GR2.1, RN10.3, U4.C12
GR2-IO2: GR2.2, RN10.4, U4.C11
GR3-IO1: GR3.1, RN11.3, U4.C14
GR3-IO2: GR3.2, RN11.4, U4.C13
HDR1-1: HDR1.1, U4.J1
HDR1-2: HDR1.2, U4.K1
HDR1-3: HDR1.3, U4.H1
HDR1-4: HDR1.4, U4.J2
HDR1-6: HDR1.6, U4.H2
HDR1-7: HDR1.7, U4.G2
HDR1-8: HDR1.8, U4.G1
HDR1-9: HDR1.9, U4.F2
HDR1-10: HDR1.10, U4.F1
HDR1-11: HDR1.11, U4.E2
HDR1-12: HDR1.12, U4.F3
HDR1-13: HDR1.13, U4.D1
HDR1-14: HDR1.14, U4.E3
HDR1-16: HDR1.16, U4.D2
HDR1-17: HDR1.17, U4.C2
HDR1-18: HDR1.18, U4.C1
HDR1-19: HDR1.19, U4.B2
HDR1-20: HDR1.20, U4.B1
LED1: LED1.2, U4.A9
LED2: LED2.2, U4.B8
LED3: LED3.2, U4.A7
LED4: LED4.2, U4.B7
unnamed: C32.1, C34.1, U4.E7
unnamed: C32.2, C34.2, R1.1, U4.E8
unnamed: C33.1, C35.1, U4.N8
unnamed: C33.2, C35.2, R6.1, U4.L8
unnamed: CON1.1, JP4.1
unnamed: D1.1, U4.E12
unnamed: GR4.3, JP2.2, PM2.6, PM2.12, SH3.1
unnamed: GR5.3, JP3.2, PM3.6, PM3.12, SH4.1
unnamed: JP1.2, RN4.2, SH5.1, U4.M10
unnamed: JP4.2, Q1.3, SH1.1
unnamed: JP5.2, RESET1.2, RN4.1, SH6.1, U4.N11
unnamed: JP6.2, SATA1.7, SATA2.7, SH2.2
unnamed: LED1.1, RN5.4
unnamed: LED2.1, RN5.3
unnamed: LED3.1, RN5.2
unnamed: LED4.1, RN5.1
unnamed: R7.2, RESET1.1
unnamed: R8.1, R9.2, U8.1
unnamed: RN2.3, SW2.1
unnamed: RN2.4, SW1.1
unnamed: RN6.1, SW3.4
unnamed: RN6.2, SW3.3
unnamed: RN6.3, SW3.2
unnamed: RN6.4, SW3.1
unnamed: RN3.1, RN12.5, U4.R11, U6.6
unnamed: RN3.2, RN12.6, U4.R12, U6.1
unnamed: RN12.7, U4.P12, U6.5
unnamed: RN12.8, U4.P11, U6.2
PM2-A1: PM2.1, U4.A1
PM2-A2: PM2.2, U4.B3
PM2-A3: PM2.3, U4.B5
PM2-A4: PM2.4, U4.B6
PM2-B1: GR4.1, PM2.7, U4.A2
PM2-B2: GR4.2, PM2.8, U4.B4
PM2-B3: PM2.9, U4.A5
PM2-B4: PM2.10, U4.A6
PM3-A1: PM3.1, U4.A11
PM3-A2: PM3.2, U4.B12
PM3-A3: PM3.3, U4.B14
PM3-A4: PM3.4, U4.B15
PM3-B1: GR5.1, PM3.7, U4.B10
PM3-B2: GR5.2, PM3.8, U4.B11
PM3-B3: PM3.9, U4.B13
PM3-B4: PM3.10, U4.A15
SATA1_A+: RN7.8, U4.L4
SATA1_A-: RN7.7, U4.L1
SATA1_B+: RN7.5, U4.K4
SATA1_B-: RN7.6, U4.M1
SATA2_A+: RN8.8, U4.M4
SATA2_A-: RN8.7, U4.P1
SATA2_B+: RN8.5, U4.R1
SATA2_B-: RN8.6, U4.N4
SD_A0: U4.F13, U5.23
SD_A1: U4.E14, U5.24
SD_A2: U4.E13, U5.25
SD_A3: U4.D14, U5.26
SD_A4: U4.B16, U5.29
SD_A5: U4.C16, U5.30
SD_A6: U4.D15, U5.31
SD_A7: U4.D16, U5.32
SD_A8: U4.E16, U5.33
SD_A9: U4.F15, U5.34
SD_A10: U4.F14, U5.22
SD_A11: U4.F16, U5.35
SD_A12: U4.G14, U5.36
SD_BS0: U4.H14, U5.20
SD_BS1: U4.G13, U5.21
SD_CKE: U4.G15, U5.37
SD_CLK: U4.G16, U4.H16, U5.38
SD_DQ0: U4.R14, U5.2
SD_DQ1: U4.P14, U5.4
SD_DQ2: U4.M13, U5.5
SD_DQ3: U4.M14, U5.7
SD_DQ4: U4.L13, U5.8
SD_DQ5: U4.L14, U5.10
SD_DQ6: U4.K13, U5.11
SD_DQ7: U4.K14, U5.13
SD_DQ8: U4.J16, U5.42
SD_DQ9: U4.L16, U5.44
SD_DQ10: U4.M16, U5.45
SD_DQ11: U4.M15, U5.47
SD_DQ12: U4.N16, U5.48
SD_DQ13: U4.P16, U5.50
SD_DQ14: U4.P15, U5.51
SD_DQ15: U4.R15, U5.53
SD_LDQM: U4.J13, U5.15
SD_UDQM: U4.J15, U5.39
SW1: SW1.2, U4.A16
SW2: SW2.2, U4.B9
USER_CLK: U4.C8, U7.3
VCCIO_3: C6.1, C19.1, C23.1, C27.1, C31.1, HDR1.5, JP6.1, R9.1, U4.E1, U4.G6, U4.J6, U4.N1, U8.2, U8.4
~SD_CAS: U4.K15, U5.17
~SD_CS: U4.H13, U5.19
~SD_RAS: U4.K16, U5.18
~SD_WE: U4.J14, U5.16

## Commit log

2018-05-27 Initial commit.
2018-05-27 Removed a Refresh() operation that is not needed. * Corrected grammar in comments.
2019-06-04 Added GitHub issue template.
2021-04-20 5.99 fixes
2021-04-20 Modified so code runs on earlier versions as well as 5.99.
2021-04-20 Updated history in README.
2021-05-19 * Modified to allow kinet2pcb to use HierPlace to do an initial placement of parts.
2021-05-19 Corrected release date in README.
2021-05-21 Made this into a PyPi project so it could be used by kinet2pcb (which is used by SKiDL).
2021-05-24 Modifications for making setup work in 2.7.18.
2021-05-24 Fixed setup.
2021-09-17 Moved from xesscorp to devbisme.
2021-09-17 Fixed improperly formatted section header.
2023-02-26 Add KiCad 7 compatibility
2023-08-10 fix: Restored compatibility with KiCad 5.
2023-08-10 chore: Updated history and version number.

Notices in the files:
tests/CAT.kicad_pcb:
(c) 2015
CC BY 4.0
